Commit message: velocity control of the wheels by ros

File: urdf/dm3.urdf (robot description, URDF)
Before this commit: robot dm3, 8 links, 7 joints
Joints:
- joint extention_to_extension: limit effort=100 velocity=100 -> lower=-1 upper=1 effort=100 velocity=100
